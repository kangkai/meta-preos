PACKAGES =+ "${PN}-preos"
FILES_${PN}-preos = "${bindir}/bzip2* \
		     ${bindir}/bunzip2* \
		    "
