PACKAGES =+ "${PN}-preos"
FILES_${PN}-preos = "${base_sbindir}/resize2fs* \
		    "
